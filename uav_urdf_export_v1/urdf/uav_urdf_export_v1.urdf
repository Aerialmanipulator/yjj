Commit message: change m-j and add readme

File: uav_urdf_export_v1/urdf/uav_urdf_export_v1.urdf (robot description, URDF)
Before this commit: robot uav_urdf_export_v1, 5 links, 4 joints
Links:
- link body: mass 0.55051 -> 2.9
